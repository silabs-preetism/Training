# Keil uVision project spi.uvprojx, settings and files
target Redpine MCU library (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.6
  cpu: IRAM(0x000000C,0x2FFF4) IROM(0x08012000,0xEE000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --output=output\spi.asm Objects\spi.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\spi.bin Objects\spi.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: __CC_ARM RSI_SAMPLE_HAL RSI_WLAN_ENABLE  NO_AES RSI_SPI_INTERFACE  RSI_LITTLE_ENDIAN HIGH_THROUGHPUT_EN
  c include: ..\..\..\..\..\include;..\..\..\..\..\rom;..\..\..\source\Common\board\inc;..\..\..\source\Common\chip\inc;..\..\..\source\Peripheral_Library\driver\inc;..\..\..\source\Common\cmsis;..\..\..\source\Peripheral_Library\cmsis_driver;..\..\..\source\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\source\Peripheral_Library\cmsis_driver\config;..\..\..\source\Peripheral_Library\driver\inc;..\..\..\source\Peripheral_Library\rom_driver\inc;..\..\..\source\Peripheral_Library\systemlevel\inc;..\..\..\..\..\examples\wlan\throughput_app;..\..\..\..\..\examples\utilities\certificates
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000 size 0x13000
  group start_up
    ../../../source/Common/chip/src/: rsi_system_config.c system_RS1xxxx.c
    ../../../source/startup/: startup_RS1xxxx.s
  group sapis
    ../../../../../common/: rsi_common_apis.c rsi_device_init_apis.c
    ../../../../../rom/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_events_rom.c rsi_nwk_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_socket_rom.c rsi_utils_rom.c
    ../../../../../nwk/socket/: rsi_socket.c
    ../../../../../driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_iap.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_wlan.c rsi_zb.c rsi_zb_utility.c
    ../../../../../wlan/: rsi_wlan_apis.c
  group example
    ../../../../../examples/wlan/throughput_app/: rsi_throughput_app.c
  group lib
    ../../../source/Peripheral_Library/driver/src/: rsi_egpio.c rsi_timers.c rsi_udma.c clock_update.c rsi_gspi.c rsi_udma_wrapper.c
    ../../../source/Common/chip/src/: rsi_ps_ram_func.c
  group power_clk
    ../../../source/Peripheral_Library/systemlevel/src/: rsi_bod.c rsi_ipmu.c rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c
  group cmsis_driver
    ../../../source/Peripheral_Library/cmsis_driver/: GSPI.c UDMA.c
  group spi
    ../../../../../driver/intf/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group hal
    ../../hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c
