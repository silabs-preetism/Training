# Keil uVision project sdio.uvprojx, settings and files
target WiseMCU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.2
  cpu: IRAM(0x000000C,0x2FFF4) IROM(0x08012000,0xEE000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tcp_client +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\tcp_client.bin Objects\tcp_client.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --Output=output\tcp_client.asm Objects\tcp_client.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __CC_ARM RSI_SAMPLE_HAL RSI_WLAN_ENABLE  RSI_LITTLE_ENDIAN  NO_AES  FULL_SPEED RSI_SDIO_INTERFACE
  c misc: --reduce_paths
  c include: ..\..\..\..\..\include;..\..\..\..\..\hal_WiSeMcu\inc;..\..\..\..\..\rom;..\..\..\source\Common\chip\inc;..\..\..\source\Common\cmsis;..\..\..\source\Peripheral_Library\driver\inc;..\..\..\source\Peripheral_Library\systemlevel\inc;..\..\..\source\Peripheral_Library\rom_driver\inc;..\..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\..\Peripheral_Library\aes_code\cyassl\ctaocrypt;..\..\..\source\Common\board\inc;..\..\..\..\..\nwk\applications;..\..\..\..\..\nwk\applications\mqtt_client\src;..\..\..\..\..\nwk\applications\mqtt_client\src\MQTTPacket\src;..\..\..\..\..\examples\utilities\certificates;..\..\..\..\..\nwk\applications\http_server;..\..\..\source\Peripheral_Library\cmsis_driver;..\..\..\source\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\source\Peripheral_Library\cmsis_driver\config;..\..\..\..\..\examples\wlan\tcp_client;..\..\..\source\Peripheral_Library\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x18500 size 0x1a800
  group start_up
    ../../../source/Common/chip/src/: rsi_system_config.c system_RS1xxxx.c
    ../../../source/startup/: startup_RS1xxxx.s
  group sapis
    ../../../../../../sapis/driver/: rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_utils.c rsi_wlan.c rsi_timer.c rsi_bt_ble.c rsi_common.c
    ../../../../../../sapis/common/: rsi_common_apis.c rsi_device_init_apis.c
    ../../../../../../sapis/wlan/: rsi_wlan_apis.c
    ../../../../../../sapis/nwk/socket/: rsi_socket.c
    ../../../../../../sapis/rom/: rsi_apis_non_rom.c
    ../../../../../../sapis/nwk/applications/: rsi_dns.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_web_socket.c
    ../../../../../../sapis/nwk/applications/mqtt_client/src/: MQTT_wrappers.c MQTTClient.c
    ../../../../../../sapis/nwk/applications/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../../../../../../sapis/nwk/applications/http_server/: rsi_http_server.c rsi_json_handlers.c
    ../../../../../../sapis/bt_ble/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_spp_apis.c
  group example
    ../../../../../examples/wlan/tcp_client/: rsi_tcp_client.c
  group sdio
    ../../../../../driver/intf/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group hal
    ../../hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_timer.c rsi_hal_mcu_sdio.c
  group board
    ../../../source/Common/board/src/: rsi_board.c
  group wisemcu_powersave
    ../../../source/Peripheral_Library/systemlevel/src/: rsi_ipmu.c rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c
    ../../../source/Common/chip/src/: rsi_ps_ram_func.c
    ../../../source/Peripheral_Library/driver/src/: rsi_udma.c rsi_udma_wrapper.c
  group uart_debug_prints
    ../../../source/Peripheral_Library/driver/src/: rsi_egpio.c rsi_sdioh.c rsi_smih.c clock_update.c rsi_usart.c
    ../../../source/Peripheral_Library/cmsis_driver/: USART.c UDMA.c
  group rom
    ../../../../../../sapis/rom/: rsi_apis_rom.c rsi_events_rom.c rsi_nwk_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_socket_rom.c rsi_utils_rom.c
