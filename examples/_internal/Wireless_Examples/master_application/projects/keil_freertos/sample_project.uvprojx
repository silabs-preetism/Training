# Keil uVision project sample_project.uvprojx, settings and files
target sample_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sample_project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,RSI_WITH_OS,RSI_SPI_INTERFACE,RSI_SAMPLE_HAL,RSI_SPI_HIGH_SPEED_ENABLE,RSI_WLAN_ENABLE,RSI_PUF_ENABLE,RSI_BLE_ENABLE,RSI_BT_ENABLE RSI_DEBUG_PRINTS
  c misc: --C99 --reduce_paths
  c include: ..\..\..\..\..\..\platforms\stm32\core\inc;..\..\..\..\..\..\platforms\stm32\drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\platforms\stm32\drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\platforms\stm32\drivers\CMSIS\Include;..\..\..\..\..\..\platforms\stm32\drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\..\third_party\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\sapi\include;..\..\..\..\..\..\sapi\network\protocols;..\..\..\..\..\..\sapi\network\protocols\http_server;..\..\..\..\..\..\sapi\network\protocols\mdnsd_records;..\..\..\..\..\..\third_party\mqtt_client\src;..\..\..\..\..\..\third_party\mqtt_client\src\MQTTPacket\src;..\..\..\..\Wireless_Examples\master_application;..\..\..\..\..\..\third_party\aws_sdk\include;..\..\..\..\..\..\third_party\aws_sdk\platform\silabs\inc;..\..\..\..\..\..\resources\certificates;..\..\..\..\..\..\platforms\stm32\boards\nucleo-f411re
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
--reduce_paths
  group example
    ../../../../Wireless_Examples/master_application/: rsi_ble_config.h rsi_bt_config.h rsi_wlan_config.h
    ../../: rsi_wlan_app.c rsi_ble_app.c main.c
  group platforms/stm32
    ../../../../../../platforms/stm32/core/startup/: startup_stm32f411xe.s
    ../../../../../../platforms/stm32/core/src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group platforms/hal
    ../../../../../../platforms/stm32/hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_timer.c
  group sapi/common
    ../../../../../../sapi/common/: rsi_common_apis.c rsi_device_init_apis.c rsi_apis_non_rom.c rsi_apis_rom.c
  group sapi/device_interface
    ../../../../../../sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
    ../../../../../../sapi/driver/device_interface/uart/: rsi_uart.c
  group sapi/wlan
    ../../../../../../sapi/wlan/: rsi_wlan_apis.c
  group sapi/rtos
    ../../../../../../sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group sapi/driver
    ../../../../../../sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_wlan.c rsi_events_rom.c rsi_nwk_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_utils_rom.c
  group sapi/include
    ../../../../../../sapi/include/: rsi_ant.h rsi_ble.h rsi_ble_apis.h rsi_ble_common_config.h rsi_bootup_config.h rsi_bt.h rsi_bt_apis.h rsi_bt_common.h rsi_bt_common_apis.h rsi_bt_common_config.h rsi_bt_sbc_codec.h rsi_bt_sdp.h rsi_common.h rsi_common_apis.h rsi_crypto.h rsi_data_types.h rsi_driver.h rsi_error.h rsi_events.h rsi_hal.h rsi_hid.h rsi_mac_api.h rsi_mac_interface.h rsi_nwk.h rsi_os.h rsi_pkt_mgmt.h rsi_qspi_defines.h rsi_queue.h rsi_scheduler.h rsi_sdio.h rsi_setregion_countryinfo.h rsi_socket.h rsi_spi_cmd.h rsi_spi_intf.h rsi_timer.h rsi_uart.h rsi_user.h rsi_utils.h rsi_wlan.h rsi_wlan_apis.h rsi_wlan_common_config.h rsi_wlan_defines.h rsi_wlan_non_rom.h
  group sapi/network
    ../../../../../../sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dhcp_user_class.h rsi_dns.c rsi_emb_mqtt_client.c rsi_emb_mqtt_client.h rsi_firmware_upgradation.c rsi_firmware_upgradation.h rsi_ftp.c rsi_http_client.c rsi_http_client.h rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mdnsd.h rsi_mqtt_client.c rsi_mqtt_client.h rsi_multicast.c rsi_multicast.h rsi_ota_fw_up.c rsi_pop3_client.c rsi_pop3_client.h rsi_raw_data.c rsi_smtp_client.c rsi_smtp_client.h rsi_sntp_client.c rsi_sntp_client.h rsi_web_socket.c rsi_web_socket.h
    ../../../../../../sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c rsi_json_handlers.h
    ../../../../../../sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c rsi_mdnsd_records.h
    ../../../../../../sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group sapi/bluetooth
    ../../../../../../sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_spp_apis.c
  group third_party/aws_sdk
    ../../../../../../third_party/aws_sdk/src/: aws_iot_jobs_interface.c aws_iot_jobs_json.c aws_iot_jobs_topics.c aws_iot_jobs_types.c aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c jsmn.c
    ../../../../../../third_party/aws_sdk/platform/silabs/src/: network_sapi_wrapper.c timer.c
  group third_party/mqtt_client
    ../../../../../../third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c StackTrace.h
    ../../../../../../third_party/mqtt_client/src/: MQTT_wrappers.h MQTTClient.c MQTTClient.h MQTT_sapi_wrappers.c
  group third_party/freertos
    ../../../../../../third_party/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../third_party/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../third_party/freertos/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.1.0
